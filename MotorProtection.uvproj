# Keil uVision project MotorProtection.uvproj, settings and files
target DEMO (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Firmware +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Code;.\Drivers;.\FreeRTOS\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Code
    ./Code/: main.c startup_stm32f030.s system_stm32f0xx.c stm32f0xx_adc.c stm32f0xx_i2c.c user_tasks.c FreeRTOSConfig.h
  group Drivers
    ./Drivers/: pcf8574.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c port.c queue.c stream_buffer.c tasks.c timers.c heap_2.c
